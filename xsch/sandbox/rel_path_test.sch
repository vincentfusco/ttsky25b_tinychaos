v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ip/logic/inv/inv.sym} -70 0 0 0 {name=X_Full_Path}
C {ip/logic/inv/inv.sym} 140 0 0 0 {name=X_Direct}
